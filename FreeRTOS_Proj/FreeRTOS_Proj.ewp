# IAR project FreeRTOS_Proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; Source\Driver\inc; Source\FreeRTOS\include; Source\FreeRTOS\portable; Source\Tasks\inc; Source\User\inc; Source\Tk_Lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: FreeRTOS_Proj.out
  ILINK.IlinkAdditionalLibs: Source\Tk_Lib\TouchPro.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptStrategy: 0
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/FMD StdDriverOne _Device.Startup_1.0.1
    RTE/Device/FT32F072R8ATx/: system_ft32f0xx.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.WWDG_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_wwdg.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.USART_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_usart.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.TIM_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_tim.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.SYSCFG_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_syscfg.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.SPI_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_spi.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.RTC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_rtc.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.RCC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_rcc.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.PWR_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_pwr.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.OPA_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_opa.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.MISC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_misc.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.IWDG_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_iwdg.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.I2C_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_i2c.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.GPIO_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_gpio.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.FLASH_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_flash.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.EXTI_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_exti.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.DMA_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_dma.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.DEBUG_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_debug.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.DAC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_dac.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.CRS_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_crs.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.CRC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_crc.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.COMP_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_comp.c
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.COMMON_1.0.1
    RTE/Device/FT32F072R8ATx/: ft32f0xx_conf.h
  group CMSIS-Pack/FMD StdDriverOne _Device.FT32Driver.ADC_1.0.1
    ${CMSIS_PACK_PATH_FMD#FT32F0xx_DFP#1.0.1}$/Drivers/FT32F0xx_Driver/Src/: FT32f0xx_adc.c
  group Driver
    Source/Driver/src/: board.c Peripheral.c
  group FreeRTOS
    Source/FreeRTOS/: list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    Source/FreeRTOS/portable/: heap_4.c port.c portasm.s
  group Startup
    Source/Startup/: startup_FT32f072.s
  group Tasks
    Source/Tasks/src/: HighProTask.c IdleTask.c InitTask.c LowProTask.c TaskManager.c
  group User
    Source/User/src/: ft32f0xx_it.c main.c
